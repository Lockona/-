# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H750xx,  LFS_CONFIG=lfs_config.h, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: applications;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\port;board\CubeMX_Config\Core\Inc;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;.\lvgl;.\lvgl\src\lv_driver;.\lvgl\src;.\applications\TOUCH;.\applications\RC522;.\rt-thread\components\drivers\wlan;.\libraries\rt_ota_lib\inc;.\packages\fal-v0.5.0\inc;.\packages\EasyFlash-v4.1.0\inc;.\rt-thread\components\net\sal_socket\include\socket\netinet;.\rt-thread\components\net\sal_socket\include;.\rt-thread\components\net\sal_socket\include\socket;.\rt-thread\components\net\sal_socket\include\socket\sys_socket\sys;.\rt-thread\components\net\netdev\include;.\rt-thread\components\net\netdev\include\arpa;.\rt-thread\components\net\sal_socket\include\dfs_net;.\rt-thread\components\net\sal_socket\include\dfs_net\sys_select\sys;.\rt-thread\components\net\sal_socket\impl;.\rt-thread\components\drivers\spi\sfud\inc;.\libraries\rt_ota_lib\inc;.\rt-thread\components\utilities\ymodem;.\rt-thread\components\drivers\spi\sfud\inc;.\rt-thread\components\dfs\filesystems\romfs;.\packages\littlefs-v2.0.5;.\applications\lv_app;.\applications\md5;.\packages\umqtt-latest\inc;.\rt-thread\components\net\sal_socket\include\socket\sys_socket;.\rt-thread\components\net\lwip-2.0.2\src\arch\include;.\rt-thread\components\net\lwip-2.0.2\src\include\lwip;.\rt-thread\components\net\lwip-2.0.2\src\include;.\rt-thread\components\net\lwip-2.0.2\src;.\packages\cJSON-v1.0.2;.\applications\OV2640
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group Applications
    ./applications/: main.c decode_dma.c umqtt_app.c
    ./applications/lv_app/: lvgl_app.c
    ./applications/sntp/: sntp.c
    ./applications/OV2640/: ov2640_app.c
    ./applications/RC522/: rc522_app.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ./rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ./rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
    ./rt-thread/components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ./rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ./rt-thread/components/drivers/spi/: spi_flash_sfud.c
    ./rt-thread/components/drivers/rtc/: rtc.c
  group Drivers
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/drivers/: drv_common.c drv_usart.c drv_gpio.c drv_spi.c drv_wlan.c drv_sdram.c drv_lcd.c
    ./libraries/drivers/: drv_dcmi.c drv_ov2640.c drv_soft_i2c.c drv_spi_flash.c drv_sdio.c drv_rtc.c
    ./board/port/: ef_fal_port.c wifi_config.c
    ./rt-thread/components/drivers/mtd/: mtd_nor.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ./rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ./rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    ./rt-thread/components/dfs/filesystems/elmfat/option/: cc936.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    ./libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dcmi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_jpeg.c
  group LVGL_Core
    ./lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ./lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c lv_font_montserrat_32.c
    ./lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
    ./lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
  group LVGL_Driver
    ./lvgl/src/lv_driver/: lv_port_disp.c lv_port_indev.c
  group lvgl_font
    ./applications/lv_app/: admin_fornt.c ebrimabd_font.c test_font_16.c test_font_24.c
  group Touch
    ./applications/TOUCH/: ctiic.c gt9147.c touch_driver.c
  group RC522
    ./applications/RC522/: rc522_config.c rc522_function.c
  group fal
    ./packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ./packages/fal-v0.5.0/samples/porting/: fal_flash_sfud_port.c
  group EasyFlash
    ./packages/EasyFlash-v4.1.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
  group lwIP
    ./rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ./rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ./rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    ./rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ./rt-thread/components/net/sal_socket/src/: sal_socket.c
    ./rt-thread/components/net/sal_socket/socket/: net_netdb.c
    ./rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
  group Utilities
    ./rt-thread/components/utilities/ymodem/: ymodem.c
  group WICED
    ./libraries/wlan_wiced_lib/: libwifi_6212_armcm7_2.1.2_armcc.lib
  group rt_ota
    ./libraries/rt_ota_lib/src/: rtota_update.c
    ./libraries/rt_ota_lib/libs/: librt_ota_armcm7_noalgo_0.2.3_keil.lib
  group littlefs
    ./packages/littlefs-v2.0.5/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group umqtt
    ./packages/umqtt-latest/src/: umqtt.c
    ./packages/umqtt-latest/src/trans/: umqtt_transport.c
    ./packages/umqtt-latest/src/pkgs/: umqtt_pkgs_decode.c umqtt_pkgs_encode.c
  group cJSON
    ./packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
